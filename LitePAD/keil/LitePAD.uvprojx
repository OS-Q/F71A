# Keil uVision project LitePAD.uvprojx, settings and files
target LitePAD (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LitePAD +hex
  AfterMake: fromelf.exe --bin -o ./LitePAD.bin ./Obj/LitePAD.axf
  c flags: Optim=1
  c include: ..\Source;..\FAT;..\JPEG;..\TEXT;..\HardWare;..\FWLib\Library\inc;..\FWLib\USBLib\inc;..\USBCONFIG;..\MUSIC;..\GUI;..\GUI\CURSOR;..\PTGAME;..\GUI\GUI2D
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../Source/: main.c sysfile.c stm32f10x_it.c
    ../FWLib/: stm32f10x_vector.s
  group FAT
    ../FAT/: FAT.C
  group GUI
    ../GUI/: gui.c picviewer.c usbplay.c mp3player.c mouseplay.c ebookplay.c timeplay.c syssetting.c
    ../PTGAME/: ptgame.c
  group FWLib
    ../FWLib/Library/src/: cortexm3_macro.s stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group GUI2D
    ../GUI/GUI2D/: GUI_FillPolygon.c GUIPolyR.c GUI2DLib.c
  group USBLib
    ../FWLib/USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group HardWare
    ../HardWare/: delay.c sys.c usart.c lcd.c touch.c flash.c sdcard.c RTC_time.c temp.c ov7670.c SCCB.c ov7670config.c
    ../MUSIC/: VS1003x.c
  group Application
    ../TEXT/: text.c untogb.c fontupd.c
    ../JPEG/: jpegdecode.c
  group USBConfig
    ../USBCONFIG/: hw_config.c mass_mal.c usb_pwr.c usb_istr.c memory.c scsi_data.c usb_bot.c usb_scsi.c usb_massdesc.c usb_massendp.c usb_massprop.c usb_mousedesc.c usb_mouseprop.c
